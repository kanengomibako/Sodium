File: KiCad/Sodium_3_frame_Acryl10mm.kicad_pcb (KiCad board)
At the start: 2 copper layers, 148 x 100 mm, 0 parts

Commit message: Update KiCad files
Other:
- outline, holes or cut-outs redrawn
